# Keil uVision project Lab_Project_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Lab_Project_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Control_Reg.c Control_Reg.h SRCLK_aliases.h SRCLK.c SRCLK.h Latch_aliases.h Latch.c Latch.h OE_aliases.h OE.c OE.h SRCLR_aliases.h SRCLR.c SRCLR.h SER_aliases.h SER.c SER.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h SRCLK_Red_aliases.h SRCLK_Red.c SRCLK_Red.h Latch_Red_aliases.h Latch_Red.c Latch_Red.h SER_Red_aliases.h SER_Red.c SER_Red.h Control_Reg_Red.c Control_Reg_Red.h SRCLK_Blue_aliases.h SRCLK_Blue.c SRCLK_Blue.h Latch_Blue_aliases.h Latch_Blue.c Latch_Blue.h SER_Blue_aliases.h SER_Blue.c SER_Blue.h Control_Reg_Blue.c Control_Reg_Blue.h isr_sleep.c isr_sleep.h SleepTimer.c SleepTimer.h isr_flash.c isr_flash.h Timer.c Timer.h Timer_PM.c CapSense_CSD.c CapSense_CSD.h CapSense_CSD_CSHL.c CapSense_CSD_CSHL.h CapSense_CSD_INT.c CapSense_CSD_Pins.c CapSense_CSD_Pins.h CapSense_CSD_PM.c CapSense_CSD_SMS_Wrapper.c CapSense_CSD_TunerHelper.c CapSense_CSD_TunerHelper.h CapSense_CSD_CompCH0.c CapSense_CSD_CompCH0.h CapSense_CSD_CompCH0_PM.c CapSense_CSD_IdacCH0.c CapSense_CSD_IdacCH0.h CapSense_CSD_IdacCH0_PM.c CapSense_CSD_AMuxCH0.c CapSense_CSD_AMuxCH0.h CapSense_CSD_IntClock.c CapSense_CSD_IntClock.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h UART.c UART.h UART_PM.c UART_INT.c UART_BOOT.c UART_IntClock.c UART_IntClock.h Timer_Sent.c Timer_Sent.h Timer_Sent_PM.c isr_Sent.c isr_Sent.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: Lab_Project_PSoC5lib (library)
